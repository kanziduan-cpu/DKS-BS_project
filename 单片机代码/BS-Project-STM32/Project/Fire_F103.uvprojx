# Keil uVision project Fire_F103.uvprojx, settings and files
target ESP8266接收控制蜂鸣器_LED灯_舵机实验 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --locale=english,--diag_suppress=870
  c include: ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\Libraries\CMSIS\CM3\CoreSupport;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../User/: system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/led/: bsp_gpio_led.c
    ../User/systick/: bsp_systick.c
    ../User/delay/: bsp_delay.c
    ../User/key/: bsp_gpio_key.c
    ../User/debug/: bsp_debug.c
    ../User/usart/: usart_com.c
    ../User/adc/: bsp_adc.c
    ../User/dwt/: bsp_dwt.c
    ../User/dht11/: bsp_dht11.c
    ../User/esp8266/: bsp_esp8266.c
    ../User/i2c/: bsp_i2c.c
    ../User/common/: common.c
    ../User/beep/: bsp_gpio_beep.c
    ../User/servo/: bsp_servo.c
    ../User/mpu6050/: bsp_i2c_mpu6050.c
    ../User/mq135/: bsp_gpio_mq135.c
    ../User/rain/: bsp_gpio_rain.c
  group APP
    ../App/led/: app_led.c
    ../App/debug/: app_debug.c
    ../App/esp8266/: app_esp8266.c
    ../App/dht11/: app_dht11.c
    ../App/mq135/: app_mq135.c
    ../App/adc/: app_adc.c
    ../App/mpu6050/: app_mpu6050.c
    ../App/beep/: app_beep.c
    ../App/servo/: app_servo.c
  group DOC
    ../Doc/: readme.txt
